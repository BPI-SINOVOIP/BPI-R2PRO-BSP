require  meta-python2-image-base.bb

SUMMARY = "meta-python2 ptest test image"

IMAGE_INSTALL += "packagegroup-meta-python2-ptest"
