require  meta-python2-image-base.bb

SUMMARY = "meta-python2 build test image"

IMAGE_INSTALL += "packagegroup-meta-python2"
